# Keil uVision project STC15W-TEST.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: STC15W-TEST +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c leds.c timer.c key.c Exint.c Uart.c Veiw.c Qudong.c Ws.c eep.c adc.c pwm.c
